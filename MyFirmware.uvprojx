# Keil uVision project MyFirmware.uvprojx, settings and files
target Firmware (6240000::V6.24::ARMCLANG)
  device: N32L403KB NSING
  pack: NSING.N32L40x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyFirmware +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20006000 size 0x2000
  group Source
    ./: foc_adc.c foc_comm.c foc_encoder.c foc_flash.c foc_motor.c foc_oled.c foc_pwm.c foc_time.c foc_utils.c main.c n32l40x_it.c
  group Headers
    ./: foc_adc.h foc_comm.h foc_encoder.h foc_flash.h foc_motor.h foc_motor_od.h foc_oled.h foc_pwm.h foc_time.h foc_utils.h n32l40x_it.h
software components: CMSIS:CORE 6.4.0, Device:N32L40x_StdPeripherals:ADC 1.0.0, Device:N32L40x_StdPeripherals:DMA 1.0.0, Device:N32L40x_StdPeripherals:FLASH 1.0.0, Device:N32L40x_StdPeripherals:GPIO 1.0.0, Device:N32L40x_StdPeripherals:I2C 1.0.0, Device:N32L40x_StdPeripherals:MISC 1.0.0, Device:N32L40x_StdPeripherals:RCC 1.0.0, Device:N32L40x_StdPeripherals:SPI 1.0.0, Device:N32L40x_StdPeripherals:TIMER 1.0.0, Device:N32L40x_StdPeripherals:USART 1.0.0, Device:Startup 1.0.0
